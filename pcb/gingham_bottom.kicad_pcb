File: pcb/gingham_bottom.kicad_pcb (KiCad board)
At the start: 2 copper layers, 285.8 x 123.8 mm, 11 parts

Commit message: Update Instructions
Other:
- rule pad_to_mask_clearance: 0.2 -> 0
